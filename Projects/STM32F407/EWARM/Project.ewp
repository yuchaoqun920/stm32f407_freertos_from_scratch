# IAR project Project.ewp, settings and files
configuration STM32F4-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_STM32F4_DISCO; UNITTEST=1
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32F4-Discovery; ..\..\..\..\stm32f407_freertos_from_scratch\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\stm32f407_freertos_from_scratch\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; F:\Didi.so\Project\stm32f407_freertos_from_scratch\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\stm32f407_freertos_from_scratch\Projects\STM32F407\Inc; ..\..\..\..\stm32f407_freertos_from_scratch\Middlewares\Third_Party\UnityTest
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\stm32f407_freertos_from_scratch\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\stm32f407_freertos_from_scratch\Projects\STM32F407\Inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F4-Discovery
    ../../../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32f407xx.s
  group Example/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c
    ../../../MIDDLEWARES/THIRD_PARTY/FreeRTOS/Source/portable/IAR/ARM_CM4F/: portasm.s
  group Unittest
    ../Src/UnityTest/: TestProductionCode.c
    ../Src/UnityTest/test_runners/: TestProductionCode_Runner.c
    ../../../Middlewares/Third_Party/UnityTest/: unity.c unity.h unity_internals.h
